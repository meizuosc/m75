global &project
&project="mt6582_evb"
